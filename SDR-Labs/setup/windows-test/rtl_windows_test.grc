options:
  parameters:
    author: K510 Digital Communications Lab
    description: 'Quick check: RTL-SDR + GNU Radio on Windows (FM band spectrum/waterfall).'
    generate_options: qt_gui
    id: rtl_windows_test
    output_language: python
    title: RTL-SDR Windows Test
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: Κεντρική συχνότητα του RTL-SDR
    gui_hint: 0,0,1,1
    label: Συχνότητα συντονισμού (MHz)
    start: '24'
    step: '0.1'
    stop: '1700'
    value: '100.0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: Κέρδος (gain) του RTL-SDR
    gui_hint: 1,0,1,1
    label: Κέρδος RF (dB)
    start: '0'
    step: '1'
    stop: '49'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: RTL-SDR sample rate
    value: '2048000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: Φάσμα ραδιοσυχνότητας (RF) γύρω από την κεντρική συχνότητα
    ctrlpanel: 'True'
    fc: freq*1e6
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0
    label1: RF
    name: '"RF Spectrum"'
    type: complex
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,2
    label0: Πεδίο συχνότητας
    label1: Waterfall
    num_tabs: '2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Φασματογράφημα (waterfall) στον χρόνο
    fc: freq*1e6
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@1
    name: '"RF Waterfall"'
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    comment: RTL-SDR dongle (RX only)
    freq0: freq*1e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
