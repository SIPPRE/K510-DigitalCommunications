options:
  parameters:
    author: K510 Digital Communications Lab
    description: Connect the RTL-SDR and look at the RF spectrum, waterfall and I/Q time waveform live (lab0-intro-sdr).
    generate_options: qt_gui
    id: sdr_first_look
    output_language: python
    title: SDR First Look (RTL-SDR)
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: Κεντρική συχνότητα του RTL-SDR
    gui_hint: 0,0,1,1
    label: Συχνότητα συντονισμού (MHz)
    start: '24'
    step: '0.1'
    stop: '1700'
    value: '100.0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: Κέρδος (gain) του RTL-SDR
    gui_hint: 1,0,1,1
    label: Κέρδος RF (dB)
    start: '0'
    step: '1'
    stop: '49'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: RTL-SDR sample rate
    value: '2048000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: Φάσμα ραδιοσυχνότητας (RF) γύρω από την κεντρική συχνότητα
    ctrlpanel: 'True'
    fc: freq*1e6
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0
    label1: RF
    name: '"RF Spectrum"'
    type: complex
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,2
    label0: Πεδίο συχνότητας
    label1: Waterfall
    label2: Πεδίο χρόνου (I/Q)
    num_tabs: '3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Ακατέργαστα δείγματα I/Q απευθείας από το SDR
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@2
    label1: I/Q
    name: '"I/Q Waveform"'
    size: '1024'
    srate: samp_rate
    type: complex
    ylabel: Πλάτος
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Φασματογράφημα (waterfall) στον χρόνο
    fc: freq*1e6
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@1
    name: '"RF Waterfall"'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq*1e6
    comment: RTL-SDR dongle (μόνο λήψη, RX only)
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
