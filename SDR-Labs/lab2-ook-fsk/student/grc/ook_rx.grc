options:
  parameters:
    author: K510 Digital Communications Lab
    description: 'RTL-SDR OOK/Morse receiver: envelope detect -> decimate to 32 kHz -> AGC -> Schmitt threshold -> recovered bit, Morse tape (time raster) + audible tone (lab2-ook-fsk).'
    generate_options: qt_gui
    id: ook_rx
    output_language: python
    title: OOK / Morse Receiver (RTL-SDR)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: RTL-SDR sample rate
    value: '2048000'
  states: {}
- name: env_decim
  id: variable
  parameters:
    comment: 'Αποδεκατισμός του περιβλήματος μετά τον ανιχνευτή: 2.048 Msps / 64 = 32 kHz'
    value: '64'
  states: {}
- name: env_rate
  id: variable
  parameters:
    comment: Ρυθμός περιβλήματος / AGC / κατωφλίου (32 kHz)
    value: samp_rate/env_decim
  states: {}
- name: tape_spu
  id: variable
  parameters:
    comment: Δείγματα ανά unit στην «Ταινία Morse» (σταθερά, ανεξάρτητα από τον ρυθμό)
    value: '4'
  states: {}
- name: tape_units
  id: variable
  parameters:
    comment: Units Morse ανά γραμμή της «Ταινίας Morse»
    value: '40'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: Κεντρική συχνότητα RTL-SDR
    gui_hint: 0,0,1,1
    label: Συχνότητα συντονισμού (MHz)
    start: '433.82'
    step: '0.001'
    stop: '434.02'
    value: '433.92'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: Κέρδος (gain) του RTL-SDR
    gui_hint: 0,1,1,1
    label: Κέρδος RF (dB)
    start: '0'
    step: '1'
    stop: '49'
    value: '30'
  states: {}
- name: bit_rate
  id: variable_qtgui_chooser
  parameters:
    comment: Πρέπει να ταιριάζει με τον ρυθμό Morse του εκπομπού
    gui_hint: 0,2,1,1
    label: Ρυθμός Morse (baud)
    label0: '500'
    label1: '1000'
    label2: '2000'
    label3: '4000'
    label4: '50'
    num_opts: '5'
    option0: '500'
    option1: '1000'
    option2: '2000'
    option3: '4000'
    option4: '50'
    type: int
    value: '1000'
  states: {}
- name: thresh_lo
  id: variable_qtgui_range
  parameters:
    comment: Κατώφλι Schmitt-trigger (ΧΑΜΗΛΟ) πάνω στο περίβλημα (envelope) μετά το AGC
    gui_hint: 0,3,1,1
    label: Κατώφλι ΧΑΜΗΛΟ
    start: '0'
    step: '0.02'
    stop: '1.5'
    value: '0.3'
  states: {}
- name: thresh_hi
  id: variable_qtgui_range
  parameters:
    comment: Κατώφλι Schmitt-trigger (ΥΨΗΛΟ)
    gui_hint: 0,4,1,1
    label: Κατώφλι ΥΨΗΛΟ
    start: '0'
    step: '0.02'
    stop: '1.5'
    value: '0.6'
  states: {}
- name: audio_on
  id: variable_qtgui_check_box
  parameters:
    comment: Ξεσίγαση του ακουστικού τόνου CW
    'false': '0'
    gui_hint: 0,5,1,1
    label: Ήχος ενεργός
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq*1e6
    comment: RTL-SDR dongle (μόνο λήψη, RX only)
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Ανίχνευση περιβλήματος (envelope detector) για OOK
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Εξομάλυνση περιβλήματος ΚΑΙ αποδεκατισμός ×64 (2.048 Msps -> 32 kHz). width ΣΤΑΘΕΡΟ (όχι δεμένο με το bit_rate) για τον ίδιο λόγο πραγματικού χρόνου με το ook_tx.grc· ζώνη αποκοπής από 2·4000+5000 = 13 kHz < 16 kHz (Nyquist στα 32 kHz)
    cutoff_freq: 2*bit_rate
    decim: env_decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.3'
    comment: max_gain περιορισμένο ώστε να μην ενισχύεται υπερβολικά ο θόρυβος στις σιωπές. Ρυθμοί για τα 32 kHz (decay 1e-3 × 64 = 0.064)· ίδιες σταθερές χρόνου με την αρχική έκδοση στα 2.048 Msps, άρα ισχύουν τα ίδια κατώφλια 0.3/0.6
    decay_rate: '0.064'
    gain: '1.0'
    max_gain: '100'
    reference: '1.0'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: 'Schmitt-trigger: ψηφιοποιεί το περίβλημα σε bit 0/1'
    high: thresh_hi
    init: '0'
    low: thresh_lo
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 32 kHz -> 48 kHz (interp=3, decim=2, λόγος ακριβής)
    decim: '2'
    interp: '3'
    type: fff
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    comment: Ακουστικός τόνος CW (700 Hz)
    freq: '700'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: 'Πύλη τόνου: ακούγεται μόνο όσο το recovered bit == 1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Mute / un-mute του ήχου
    const: audio_on
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Ακούστε το Morse σαν CW τόνο
    samp_rate: '48000'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,6
    label0: Φάσμα RF
    label1: Waterfall
    label2: Περίβλημα + recovered bit
    label3: Ταινία Morse
    num_tabs: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: Φάσμα ραδιοσυχνότητας (RF) γύρω από την κεντρική συχνότητα
    ctrlpanel: 'True'
    fc: freq*1e6
    fftsize: '16384'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0
    label1: RF
    name: '"RF Spectrum"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: 'Φασματογράφημα (waterfall). ΠΡΟΣΟΧΗ: μία γραμμή ανά update_time (0.1 s), και κάθε γραμμή είναι ΕΝΑ FFT 1024 δειγμάτων (0.5 ms)· τα ενδιάμεσα δείγματα απορρίπτονται. Δείχνει συχνότητα, ριπές και περίοδο, όχι μεμονωμένες τελείες Morse.'
    fc: freq*1e6
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@1
    int_max: '0'
    int_min: '-60'
    name: '"RF Waterfall"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 'Περίβλημα (μετά AGC) και ανακτημένο bit, στα 32 kHz. size=32000 -> παράθυρο 1 s (50 units στα 50 baud, ολόκληρο το μήνυμα από 500 baud και πάνω). Trigger AUTO στην ανερχόμενη ακμή του bit (κανάλι 1): η εικόνα «στέκεται»· χωρίς ακμές τρέχει ελεύθερα. Δεξί κλικ -> Stop για πάγωμα, Number of Points για άλλο παράθυρο.'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@2
    label1: Περίβλημα (AGC)
    label2: Recovered bit
    name: '"Envelope + Bits"'
    nconnections: '2'
    size: '32000'
    srate: env_rate
    tr_chan: '1'
    tr_delay: '0.02'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ylabel: Στάθμη
    ymax: '1.5'
    ymin: '-0.2'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: 'Κρατά 1 στα 32000/(4·bit_rate) δείγματα -> 4 δείγματα ανά unit σε κάθε ρυθμό (50 baud: n=160, 4000 baud: n=2). Σήμα 0/1, δεν χρειάζεται φίλτρο. Το n αλλάζει live με το bit_rate.'
    n: int(env_rate/(tape_spu*bit_rate))
    type: float
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    comment: '«Ταινία Morse»: το recovered bit σε γραμμές των tape_units (40) units· κάθε γραμμή συνεχίζει από εκεί που σταμάτησε η προηγούμενη. Το πλάτος γραμμής είναι ΣΤΑΘΕΡΟ (160 στήλες = 40 units × 4)· με το bit_rate αλλάζει μόνο ο αποδεκατισμός πριν από εδώ, άρα ο άξονας x μένει πάντα σε units. (Αλλαγή του ncols εν ώρα εκτέλεσης χαλάει τον άξονα στο GNU Radio 3.10.)'
    gui_hint: qtgui_tab_widget_0@3
    label1: Recovered bit
    name: '"Ταινία Morse (1 γραμμή = 40 units)"'
    ncols: tape_units*tape_spu
    nrows: '30'
    samp_rate: tape_spu*bit_rate
    type: float
    x_end_value: tape_units
    x_label: '"units (1 unit = 1/R)"'
    x_start_value: '0'
    y_end_value: '30'
    y_label: '"γραμμή"'
    y_start_value: '0'
    zmin: '0'
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_agc2_xx_0, '0']
- [analog_agc2_xx_0, '0', blocks_threshold_ff_0, '0']
- [analog_agc2_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_threshold_ff_0, '0', rational_resampler_xxx_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_raster_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
