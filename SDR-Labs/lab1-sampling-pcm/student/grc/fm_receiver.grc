options:
  parameters:
    author: K510 Digital Communications Lab
    description: RTL-SDR wideband FM receiver for Lab 1 (Sampling & PCM)
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: FM Receiver (RTL-SDR)
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    comment: Audio output rate
    value: '48000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: FM tuning frequency
    gui_hint: 0,0,1,1
    label: Tuning Frequency (MHz)
    start: '87.5'
    step: '0.1'
    stop: '108'
    value: '100.3'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    comment: Quadrature rate after LPF (samp_rate/8)
    value: int(samp_rate/8)
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: RTL-SDR RF gain (dB)
    gui_hint: 1,0,1,1
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '49'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: RTL-SDR sample rate
    value: '2048000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.5433'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    comment: Wideband FM demodulation
    quad_rate: quad_rate
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '1'
    deemph_tau: '75e-6'
    quad_rate: quad_rate
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Channel select + decimate to quad_rate
    cutoff_freq: 100e3
    decim: '8'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: RF spectrum
    ctrlpanel: 'True'
    fc: freq*1e6
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,1
    name: '"RF Spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '256000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"Pilot"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: RF waterfall
    fc: freq*1e6
    fftsize: '1024'
    gui_hint: 3,0,1,1
    name: '"RF Waterfall"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 256k -> 48k (x3 / /16)
    decim: '16'
    interp: '3'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '3'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '3'
    type: fff
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq*1e6
    comment: RTL-SDR dongle (RX only)
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_pll_0, '0', rational_resampler_xxx_1, '0']
- [analog_wfm_rcv_pll_0, '1', rational_resampler_xxx_2, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_1, '0']
- [rational_resampler_xxx_2, '0', audio_sink_1, '1']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
