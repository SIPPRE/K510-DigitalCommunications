options:
  parameters:
    author: K510 Digital Communications Lab
    description: Audio decimation & anti-alias filtering demo (simulation only)
    generate_options: qt_gui
    id: audio_sampling
    output_language: python
    title: Audio Sampling & Anti-Alias Filter
  states: {}

blocks:
- name: D
  id: variable_qtgui_chooser
  parameters:
    comment: Decimation factor -> effective rate = samp_rate / D
    gui_hint: 0,0,1,1
    label: Παράγοντας υποδειγματοληψίας
    label0: D=1  →  48 kHz
    label1: D=2  →  24 kHz
    label2: D=4  →  12 kHz
    label3: D=8  →  6 kHz
    label4: D=12 →  4 kHz
    num_opts: '5'
    option0: '1'
    option1: '2'
    option2: '4'
    option3: '8'
    option4: '12'
    type: int
    value: '4'
  states: {}
- name: aa_cutoff
  id: variable
  parameters:
    comment: Anti-alias cutoff (just below new Nyquist)
    value: nyq*0.85
  states: {}
- name: aa_on
  id: variable_qtgui_check_box
  parameters:
    comment: Anti-alias low-pass filter before decimation (ON = no aliasing)
    'false': '0'
    gui_hint: 0,1,1,1
    label: Αντι-αναδιπλωτικό φίλτρο
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: aa_trans
  id: variable
  parameters:
    comment: Anti-alias transition width
    value: nyq*0.2
  states: {}
- name: nyq
  id: variable
  parameters:
    comment: New Nyquist after decimation
    value: samp_rate/(2*D)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Base sample rate (fixed)
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Hear the decimated/reconstructed audio
    samp_rate: '48000'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: 'Decimation: keep 1 of every D samples (rate -> samp_rate/D)'
    n: D
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: in0 = filtered, in1 = bypass; index = 0 if aa_on else 1
    enabled: 'True'
    input_index: 0 if aa_on else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Pace simulation at samp_rate
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: 48 kHz mono test file (generated by make_test_wav.py)
    file: media/test_chirp.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Anti-alias LPF at the new Nyquist (filtered branch)
    cutoff_freq: aa_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: aa_trans
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    comment: Reconstructed-signal spectrum
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0
    label1: Ανακατασκευασμένο
    name: '"Φάσμα"'
    type: float
    ymin: '-100'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,4
    label0: Φάσμα (μετά την ανακατασκευή)
    label1: Χρόνος (μετά την ανακατασκευή)
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Reconstructed-signal waveform
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1
    label1: Ανακατασκευασμένο
    name: '"Χρόνος"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Πλάτος
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Reconstruction back to 48 kHz (interp = D)
    decim: '1'
    interp: D
    type: fff
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', rational_resampler_xxx_0, '0']
- [blocks_selector_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_throttle_0, '0', blocks_selector_0, '1']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [low_pass_filter_0, '0', blocks_selector_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
