options:
  parameters:
    author: K510 Digital Communications Lab
    description: 'Quantization & PCM: SQNR vs bits (simulation only)'
    generate_options: qt_gui
    id: quantization_pcm
    output_language: python
    title: Quantization & PCM (Kvantisi)
  states: {}

blocks:
- name: audio_on
  id: variable_qtgui_check_box
  parameters:
    comment: Un-mute to hear the quantized signal
    'false': '0'
    gui_hint: 0,2,1,1
    label: Αναπαραγωγή ήχου
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: q_bits
  id: variable_qtgui_range
  parameters:
    comment: Πλήθος bits κβάντισης
    gui_hint: 0,1,1,1
    label: Bits κβάντισης
    rangeType: int
    start: '1'
    step: '1'
    stop: '16'
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Base sample rate (fixed)
    value: '48000'
  states: {}
- name: src_sel
  id: variable_qtgui_chooser
  parameters:
    comment: Πηγή σήματος
    gui_hint: 0,0,1,1
    label: Πηγή
    label0: Ημίτονο 1 kHz
    label1: Αρχείο ήχου (WAV)
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: Ημίτονο 1 kHz, πλήρης κλίμακα
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Άκου το κβαντισμένο σήμα
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: αποφυγή διαίρεσης με το μηδέν
    const: '1e-12'
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: λόγος ισχύος
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: μέση ισχύς σήματος
    length: '4800'
    max_iter: '4800'
    scale: 1.0/4800
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    comment: μέση ισχύς σφάλματος
    length: '4800'
    max_iter: '4800'
    scale: 1.0/4800
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Mute / un-mute gate
    const: audio_on
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: ισχύς σήματος (τετράγωνο)
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    comment: ισχύς σφάλματος (τετράγωνο)
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: 10*log10 -> dB
    k: '0'
    n: '10'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: in0 = ημίτονο, in1 = WAV· index = src_sel
    enabled: 'True'
    input_index: src_sel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: σφάλμα = αρχικό - κβαντισμένο
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Pace simulation at samp_rate
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Ίδιο αρχείο με το audio_sampling.grc
    file: media/test_chirp.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """
          Κβαντιστής (mid-rise ομοιόμορφος κβαντιστής) στο διάστημα [-1, 1).

          Παράμετρος:
              bits : αριθμός bits κβάντισης  ->  πλήθος σταθμών = 2**bits.

          Για κάθε δείγμα x:
              1) Περιορισμός (clipping) του x στο [-1, 1).
              2) levels = 2**bits,   βήμα κβάντισης = 2/levels.
              3) out = (floor(x * levels/2) + 0.5) * 2/levels
                 -> mid-rise: καμία στάθμη ακριβώς στο 0, συμμετρικές στάθμες.

          Όσο λιγότερα bits, τόσο μεγαλύτερο το βήμα και ο θόρυβος κβάντισης,
          άρα μικρότερο SQNR (~6.02*bits + 1.76 dB για ημίτονο πλήρους κλίμακας).
          """

          def __init__(self, bits=8):
              gr.sync_block.__init__(
                  self,
                  name='Κβαντιστής',
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )
              # Απλό attribute -> γίνεται callback, ώστε το πλήθος bits να αλλάζει
              # ζωντανά από το QT GUI Range widget όσο τρέχει το flowgraph.
              self.bits = bits

          def work(self, input_items, output_items):
              x = input_items[0]
              levels = 2 ** int(self.bits)          # πλήθος σταθμών κβάντισης
              step = 2.0 / levels                   # βήμα κβάντισης Δ
              # Clipping στο [-1, 1): κάνουμε το άνω άκρο "ανοιχτό" ώστε το x=1
              # να μη δημιουργεί επιπλέον στάθμη υπερχείλισης.
              hi = np.nextafter(np.float32(1.0), np.float32(0.0))
              xc = np.clip(x, -1.0, hi)
              # Mid-rise ομοιόμορφη κβάντιση, διανυσματικά με numpy.
              codes = np.floor(xc * (levels / 2.0))
              y = (codes + 0.5) * step
              output_items[0][:] = y.astype(np.float32)
              return len(output_items[0])
    bits: q_bits
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: Στάθμη θορύβου κβάντισης
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1
    label1: Αρχικό
    label2: Κβαντισμένο
    name: '"Φάσμα"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    comment: Λόγος σήματος προς θόρυβο κβάντισης
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,3,1,1
    label1: SQNR (dB)
    max: '130'
    min: '-10'
    name: '"SQNR"'
    type: float
    unit1: dB
    update_time: '0.5'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,4
    label0: Χρόνος (κυματομορφή)
    label1: Φάσμα (θόρυβος κβάντισης)
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Αρχικό vs κβαντισμένο (σκάλα)
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0
    label1: Αρχικό
    label2: Κβαντισμένο
    name: '"Κυματομορφή"'
    nconnections: '2'
    size: '240'
    srate: samp_rate
    type: float
    ylabel: Πλάτος
    ymax: '1.2'
    ymin: '-1.2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0, '1']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_moving_average_xx_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_selector_0, '0', blocks_throttle_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '1']
- [blocks_throttle_0, '0', blocks_sub_xx_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '1']
- [epy_block_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0, '0', blocks_sub_xx_0, '1']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '1']
- [epy_block_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
