options:
  parameters:
    author: K510 Digital Communications Lab
    description: 'Delta Modulation: slope overload vs granular noise (simulation only)'
    generate_options: qt_gui
    id: delta_modulation
    output_language: python
    title: Delta Modulation (DM)
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    comment: Πλάτος του τόνου
    gui_hint: 1,2,1,2
    label: Πλάτος
    start: '0.1'
    step: '0.05'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: audio_on
  id: variable_qtgui_check_box
  parameters:
    comment: Un-mute reconstructed audio
    'false': '0'
    gui_hint: 0,1,1,1
    label: Αναπαραγωγή ήχου
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: delta
  id: variable_qtgui_range
  parameters:
    comment: Βήμα Δ του ολοκληρωτή (log-ish, γραμμικά βήματα)
    gui_hint: 2,0,1,2
    label: Βήμα Δ
    start: '0.005'
    step: '0.005'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: lpf_delay
  id: variable
  parameters:
    comment: Group delay of the 4 kHz reconstruction LPF (57 taps)
    value: '28'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Base sample rate (fixed)
    value: '48000'
  states: {}
- name: src_sel
  id: variable_qtgui_chooser
  parameters:
    comment: Πηγή σήματος
    gui_hint: 0,0,1,1
    label: Πηγή
    label0: Ημίτονο
    label1: Αρχείο ήχου (WAV)
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: tone_freq
  id: variable_qtgui_range
  parameters:
    comment: Συχνότητα του τόνου
    gui_hint: 1,0,1,2
    label: Συχνότητα τόνου (Hz)
    start: '100'
    step: '50'
    stop: '5000'
    value: '1000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    comment: Ημίτονο (ρυθμιζόμενη συχνότητα/πλάτος)
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Άκου το ανακατασκευασμένο σήμα
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: αποφυγή διαίρεσης με το μηδέν
    const: '1e-12'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Ευθυγράμμιση με την καθυστέρηση του LPF
    delay: lpf_delay
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: λόγος ισχύος
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: μέση ισχύς σήματος
    length: '4800'
    max_iter: '4800'
    scale: 1.0/4800
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    comment: μέση ισχύς σφάλματος
    length: '4800'
    max_iter: '4800'
    scale: 1.0/4800
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Mute / un-mute gate
    const: audio_on
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: ισχύς σήματος
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    comment: ισχύς σφάλματος
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: 10*log10 -> dB
    k: '0'
    n: '10'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: in0 = ημίτονο, in1 = WAV· index = src_sel
    enabled: 'True'
    input_index: src_sel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: σφάλμα = αρχικό - ανακατασκευασμένο
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Pace simulation at samp_rate
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Ίδιο αρχείο με τα υπόλοιπα flowgraphs
    file: media/test_chirp.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """
          Διαμορφωτής / Αποδιαμορφωτής Δέλτα (Delta Modulation, DM).

          Παράμετρος:
              delta : βήμα (step size) του ολοκληρωτή.

          Για κάθε δείγμα x[n], με «κατάσταση» = τρέχουσα τιμή του ολοκληρωτή (σκάλα):
              1) bit = +1 αν x[n] >= κατάσταση, αλλιώς -1  (σύγκριση με τον ολοκληρωτή)
              2) κατάσταση += bit * delta                  (ολοκλήρωση ±delta)

          Έξοδοι:
              out0 : η ροή bits ως ±1 (float)
              out1 : η «σκάλα» του αποκωδικοποιητή (η τιμή του ολοκληρωτή)· σε ιδανική
                     DM ο αποκωδικοποιητής αναπαράγει ακριβώς τον ολοκληρωτή του πομπού.

          Η DM είναι αναδρομική (κάθε δείγμα εξαρτάται από το προηγούμενο), γι' αυτό ο
          πυρήνας είναι σειριακός βρόχος και ΔΕΝ διανυσματοποιείται πλήρως με numpy.

          Συμπεριφορά που θα παρατηρήσετε:
            * Μικρό delta  -> υπερφόρτωση κλίσης (slope overload) στις γρήγορες μεταβολές.
            * Μεγάλο delta -> κοκκώδης θόρυβος (granular noise) στα αργά/σταθερά τμήματα.
          """

          def __init__(self, delta=0.05):
              gr.sync_block.__init__(
                  self, name='Διαμορφωτής/Αποδιαμορφωτής Δέλτα',
                  in_sig=[np.float32], out_sig=[np.float32, np.float32])
              # Απλά attributes -> το delta γίνεται live callback· το state διατηρείται.
              self.delta = delta
              self.state = 0.0   # τιμή ολοκληρωτή, διατηρείται μεταξύ κλήσεων work()

          def work(self, input_items, output_items):
              x = input_items[0]
              bits = output_items[0]
              stair = output_items[1]
              state = self.state
              d = float(self.delta)
              for i in range(len(x)):
                  b = 1.0 if x[i] >= state else -1.0   # bit πρόσημου
                  state += b * d                        # ολοκλήρωση
                  bits[i] = b
                  stair[i] = state
              self.state = state
              return len(x)
    delta: delta
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: 'Ανακατασκευή: βαθυπερατό ~4 kHz στη σκάλα'
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: Αρχικό vs ανακατασκευασμένο
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@2
    label1: Αρχικό
    label2: Ανακατασκευασμένο
    name: '"Φάσμα"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    comment: Σήμα προς θόρυβο (original vs reconstructed)
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,2,1,2
    label1: SQNR (dB)
    max: '60'
    min: '-10'
    name: '"SQNR"'
    type: float
    unit1: dB
    update_time: '0.5'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,1,4
    label0: Κυματομορφές
    label1: Ροή bits
    label2: Φάσμα
    num_tabs: '3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Αρχικό + σκάλα + ανακατασκευασμένο
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0
    label1: Αρχικό
    label2: Σκάλα (ολοκληρωτής)
    label3: Ανακατασκευασμένο
    name: '"Κυματομορφές"'
    nconnections: '3'
    size: '240'
    srate: samp_rate
    type: float
    ylabel: Πλάτος
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    comment: Η ροή bits ως ±1
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1
    label1: bit ±1
    name: '"Ροή bits"'
    size: '240'
    srate: samp_rate
    type: float
    ylabel: bit
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_sub_xx_0, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_moving_average_xx_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_selector_0, '0', blocks_throttle_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '1']
- [epy_block_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0, '1', low_pass_filter_0, '0']
- [epy_block_0, '1', qtgui_time_sink_x_0, '1']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', blocks_sub_xx_0, '1']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
